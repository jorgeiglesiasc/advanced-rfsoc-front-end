options:
  parameters:
    generate_options: qt_gui
    id: UDP_DMA
    output_language: python
    title: UDP_DMA
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3600000000/(8*100)
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/4
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1,1,1,1)
    num_outputs: '4'
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '8000'
    port: '5005'
    src_zeros: 'False'
    type: short
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '200'
    nconnections: '2'
    size: '2000'
    type: float
    xmax: '100'
    xmin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    size: '64'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', qtgui_histogram_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_real_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_stream_demux_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_demux_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_stream_demux_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_demux_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_stream_demux_0, '1', qtgui_time_sink_x_1, '1']
- [blocks_stream_demux_0, '2', qtgui_freq_sink_x_0_0, '2']
- [blocks_stream_demux_0, '2', qtgui_time_sink_x_1, '2']
- [blocks_stream_demux_0, '3', qtgui_freq_sink_x_0_0, '3']
- [blocks_stream_demux_0, '3', qtgui_time_sink_x_1, '3']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [network_udp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
